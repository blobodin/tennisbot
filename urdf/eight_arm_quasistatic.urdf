Commit message: Moved tip position to paddle and started eight dof traj

File: urdf/eight_arm_quasistatic.urdf (robot description, URDF)
Before this commit: robot eight_arm, 27 links, 26 joints
Joints:
- joint final: origin xyz=0 0.02 0 rpy=0 0 0 -> xyz=0.4 0.02 0 rpy=0 0 0
